Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-03-07T09:38:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 07 09:38:06 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\6f7c0f56-be02-4782-8f20-894614365731\3c5a8d75-008b-4547-9698-13f84f736987\ifc * Database version: 5507 * Database creation date: Tue Mar 07 09:38:06 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 07 09:38:06 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 07 09:38:06 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 10847540_I_DA2808_EDST:28280855_I_10847540_DA2808_EDST, (2)
In: Default
Type - Material: z_Miele_Design_Zinc_Steel
Type - Pset_BuildingElementProxyCommon - Reference: 28280855_I_10847540_DA2808_EDST
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 28280855_I_10847540_DA2808_EDST
Material: z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric, z_Miele_Connection_ExhaustAir, z_Miele_Design_CLST, Aluminum, z_Miele_Design_GRGR, z_Miele_Design_Glass
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 880 mm; Height: 342 mm; Depth: 500 mm
